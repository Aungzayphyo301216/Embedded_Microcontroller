# Keil uVision project x_for_p1&x^2_for_p2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51ED2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x6FF) CLOCK(33000000) MODP2
  output: x_for_p1&x^2_for_p2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: xvalue.asm
